# IAR project Project.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZE ST STM32F746ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_CORTEX_M7
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\os; ..\..\..\..\common_cortex\inc; ..\..\..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..\.
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common_cortex\src\stm32f746xE.icf
  ILINK.IlinkExtraOptions: --no_remove --no_fragments
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../../common/: shell.c
  group common_cortex
    ../../../../common_cortex/src/: startup_stm32f746xx_iar.s stm32f4xx_dma.c stm32f4xx_gpio.c stm32f7_uart.c system_stm32f746.c
  group Include
    ../: prj_conf.h project_main.h stm32f7xx_conf.h system_stm32f746.h tn_config.h
    ../../: shell.h
  group os
    ../../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
