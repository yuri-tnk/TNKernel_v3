# Keil uVision project Project.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_CORTEX_M7
  c include: ..\..\..\..\os;..\..\..\CortexM0_M7;;..\..\..\..\common_cortex\inc;..\..\..\..\common;..\
  asm misc: --cpreproc
  asm include: ../
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\common_cortex\src\Project_STM32F746.sct
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
  group common_cortex
    ../../../../common_cortex/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f7_uart.c system_stm32f746.c startup_stm32f746xx_keil.s
  group common
    ../../../../common/: shell.c
