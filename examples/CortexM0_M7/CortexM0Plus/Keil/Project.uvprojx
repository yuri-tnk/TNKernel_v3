# Keil uVision project Project.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\os;..\..\..\CortexM0_M7;..\..\..\..\common_cortex\inc;..\;..\..\..\..\common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
    ../../../../common_cortex/src/: startup_stm32l053xx_keil.s
  group common_cortex
    ../../../../common_cortex/src/: stm32l0_uart.c system_stm32l0xx.c
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7_asm.S tn_port_CortexM0_M7.c
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
  group common
    ../../../../common/: shell.c
