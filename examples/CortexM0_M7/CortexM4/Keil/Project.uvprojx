# Keil uVision project Project.uvprojx, settings and files
target Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_CortexM4 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_CORTEX_M4
  c include: ..\;..\..\..\..\os;..\..\..\CortexM0_M7;..\..\..\..\common_cortex\inc;..\..\..\..\common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Prj
    ../: project_main.c tn_user.c prj_shell_func.c
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
    ../../../../os/: tn.c tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c
  group common_cortex
    ../../../../common_cortex/src/: stm32f4_uart.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c system_stm32f4xx.c startup_stm32f746xx_keil.s
  group common
    ../../../../common/: shell.c
