# Keil uVision project Project.uvprojx, settings and files
target LPC1766 Dev Board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1776 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\..\..\os;..\..\..\CortexM0_M7;..\..\..\..\common_cortex\inc;..\;..\..\..\..\common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\common_cortex\src\CortexM3.sct
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
  group common_cortex
    ../../../../common_cortex/src/: lpc17xx_core.c lpc17xx_uart.c system_lpc176x.c lpc17xx_startup_hardware_init.S tn_LPC17xx_Startup_keil.s
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7_asm.S tn_port_CortexM0_M7.c
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
  group common
    ../../../../common/: shell.c
