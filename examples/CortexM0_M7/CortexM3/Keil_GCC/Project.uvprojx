# Keil uVision project Project.uvprojx, settings and files
target LPC1766 Dev Board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1776 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: "C:\Program Files (x86)\GNU Tools ARM Embedded\5.3 2016q1\bin\arm-none-eabi-size.exe" -A ./objects/Project.elf
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
  group common_cortex
    ../../../../common_cortex/src/: lpc17xx_core.c lpc17xx_uart.c system_lpc176x.c lpc17xx_startup_hardware_init.S tn_LPC17XX_Startup_gcc.s
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7_asm.S tn_port_CortexM0_M7.c
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
  group common
    ../../../../common/: shell.c
