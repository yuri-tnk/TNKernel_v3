# Keil uVision project Example_STM32F070R.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Example_STM32F070R
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\..\..\os;..\..\..\CortexM0_M7;..\..\..\..\common_cortex\inc;..\;..\..\..\..\common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group os
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7_asm.S tn_port_CortexM0_M7.c
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
  group PrjBase
    ../: prj_shell_func.c project_main.c tn_user.c
    ../../../../common_cortex/src/: startup_stm32f0xx_keil.s
  group common_cortex
    ../../../../common_cortex/src/: stm32f0_uart.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c system_stm32f0xx.c
  group common
    ../../../../common/: shell.c
