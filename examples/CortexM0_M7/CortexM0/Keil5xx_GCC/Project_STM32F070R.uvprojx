# Keil uVision project Project_STM32F070R.uvprojx, settings and files
target Nucleo (ARM-GNU)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project_STM32F070R +hex
  AfterMake: "C:\Program Files (x86)\GNU Tools ARM Embedded\5.3 2016q1\bin\arm-none-eabi-size.exe" -A ./objects/Project_STM32F070R.elf
  group os
    ../../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_alloc.c
    ../../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: prj_shell_func.c project_main.c tn_user.c
  group common_cortex
    ../../../../common_cortex/src/: stm32f0_uart.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c system_stm32f0xx.c tn_STM32F070_Startup_gcc.s
  group common
    ../../../../common/: shell.c
