# Keil uVision project Project.uvproj, settings and files
target example_LPC2368 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2368 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: test_arm +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\;..\..\..\..\os;..\..\..\..\common_arm\inc;..\..\..\..\common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Prj
    ../: project_main.c tn_user.c prj_shell_func.c
    ../../../../common_arm/src/: tnkernel_startup_keil_LPC23xx.s
  group common
    ../../../../common/: shell.c
  group common_arm
    ../../../../common_arm/src/: lpc236x_uart.c system_lpc236x.c startup_hardware_init_LPC236x.S
  group os
    ../../../../os/ARM/: tn_port_arm_asm.S tn_port_arm.c
    ../../../../os/: tn.c tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c
