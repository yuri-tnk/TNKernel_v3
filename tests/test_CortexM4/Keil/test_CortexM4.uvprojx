# Keil uVision project test_CortexM4.uvprojx, settings and files
target Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_CortexM4 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_CORTEX_M4
  c misc: -Ospace
  c include: ..\;..\..\..\os;..\..\CortexM0_M7;..\..\..\common_cortex\inc;..\..\..\common;..\..\..\tests\test_common
  asm misc: --cpreproc
  asm include: ..\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
    ./: startup_stm32f446xx_keil.o
  group os
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
    ../../../os/: tn_utils.c tn_timer.c tn_task.c tn_sys.c tn_sem.c tn_mutex.c tn_mem.c tn_mailbox.c tn_event.c tn_dqueue.c tn.c tn_alloc.c
  group common_cortex
    ../../../common_cortex/src/: stm32f4_uart.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c system_stm32f4xx.c
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
