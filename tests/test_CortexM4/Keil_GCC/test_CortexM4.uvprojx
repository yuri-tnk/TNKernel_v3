# Keil uVision project test_CortexM4.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_CortexM4 +hex
  AfterMake: "C:\Program Files (x86)\GNU Tools ARM Embedded\7 2017-q4-major\bin\arm-none-eabi-size.exe" -A ./objects/test_CortexM4.elf
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
    ../../../common_cortex/src/: tn_stm32f446_Startup_gcc.s
  group os
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
    ../../../os/: tn_utils.c tn_timer.c tn_task.c tn_sys.c tn_sem.c tn_mutex.c tn_mem.c tn_mailbox.c tn_event.c tn_dqueue.c tn.c tn_alloc.c
  group common_cortex
    ../../../common_cortex/src/: stm32f4_uart.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c system_stm32f4xx.c
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
