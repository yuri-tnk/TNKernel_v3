# IAR project test_CortexM4_FP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IE ST STM32F407IE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..; ..\; ..\..\..\common_ARM_Cortex; ..\..\..\common_ARM_Cortex\TARGET_NXP\TARGET_LPC176X; ..\..\test_common; ..\..\..\common_ARM_Cortex\ST\STM32F4xx\Include; ..\..\..\common; ..\..\..\os; ..\..\..\os\CortexM0_M7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main_1.c
    ../: startup_stm32f4xx.s tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_dqueue.c tn_event.c tn_mailbox.c tn_malloc.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M7
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.s
