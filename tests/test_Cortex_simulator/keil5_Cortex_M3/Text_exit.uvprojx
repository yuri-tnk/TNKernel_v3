# Keil uVision project Text_exit.uvprojx, settings and files
target Tst_exit (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Text_exit
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\keil5_Cortex_M3;..\..\..\os
  asm include: ..\keil5_Cortex_M3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group os
    ../../../os/: tn.c tn_dqueue.c tn_event.c tn_mailbox.c tn_malloc.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_port.h
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.s
  group pr
    ../: main.c
    ./: prj_conf.h tn_config.h startup_stm32f3xx_keil.s
