# IAR project TNKernel_3_tests_msp430x.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\..\test_common; ..\..\test_msp430x; ..\..\..\common; ..\..\..\os; ..\..\..\os\MSP430X
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..\
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5359.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group common
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/MSP430X
    ../../../os/MSP430X/: tn_port_MSP430X.asm tn_port_MSP430X_iar.c
  group test_common
    ../../test_common/: test.h test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
  group test_msp430x
    ../: hardware_init.c main.c pmm.c pmm.h prj_conf.h project_main.h tn_config.h tn_user.c uart.c uart.h utils_arch.c
