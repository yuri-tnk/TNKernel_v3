<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TNKernel_3_tests_msp430x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


