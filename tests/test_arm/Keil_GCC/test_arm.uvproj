# Keil uVision project test_arm.uvproj, settings and files
target test_LPC2368 (ARM-GNU)
  device: LPC2368 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: test_LPC2368 +hex
  AfterMake: C:\Sourcery_CodeBench_Lite_for_ARM_EABI\bin\arm-none-eabi-size.exe  -A ./objects/test_LPC2368.elf
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
    ../../../common_arm/src/: tnkernel_startup_gcc_LPC23xx.s
  group common
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
  group common_arm
    ../../../common_arm/src/: lpc236x_uart.c system_lpc236x.c startup_hardware_init_LPC236x.S
  group os
    ../../../os/ARM/: tn_port_arm.c tn_port_arm_asm.S
    ../../../os/: tn.c tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
