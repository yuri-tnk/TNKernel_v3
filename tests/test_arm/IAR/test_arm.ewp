# IAR project test_arm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\os; ..\..\..\common_arm\inc; ..\..\..\common; ..\..\..\tests\test_common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..\.
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common_arm\src\LPC2368_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../../common/: shell.c shell.h test_shell_func.c tn_sprintf.c utils.c
  group common_arm
    ../../../common_arm/src/: lpc236x_uart.c startup_hardware_init_LPC236x.S system_lpc236x.c tnkernel_startup_iar_LPC23xx.s
    ../../../common_arm/inc/: lpc236x_uart.h system_lpc236x.h
  group Include
    ../: project_main.h tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
    ../../../os/ARM/: tn_port_arm.c tn_port_arm_asm.S
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
  group test_common
    ../../test_common/: test.h test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
