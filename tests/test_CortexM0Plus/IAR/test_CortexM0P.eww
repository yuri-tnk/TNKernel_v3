<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test_CortexM0P.ewp</path>
  </project>
  <batchBuild/>
</workspace>


