# IAR project test_CortexM0P.ewp, settings and files
configuration test_CortexM0P (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\os; ..\..\..\common_cortex\inc; ..\..\..\common; ..\..\..\tests\test_common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: test_CortexM0P.hex
  ILINK.IlinkOutputFile: test_CortexM0P.out
  ILINK.IlinkIcfFile: ..\..\..\common_cortex\src\stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../common/: shell.c shell.h tn_sprintf.c utils.c
  group common_cortex
    ../../../common_cortex/src/: startup_stm32l053xx_iar.s stm32l0_uart.c system_stm32l0xx.c
  group Include
    ../: prj_conf.h project_main.h tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M3
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: prj_test_cm0p_shell_func.c project_main.c tn_user.c utils_arch.c
  group test_common
    ../../test_common/: test_common.c test_timer.c test_utils.c
