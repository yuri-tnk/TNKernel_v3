# IAR project test_CortexM0.ewp, settings and files
configuration test_CortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F070RB ST STM32F070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\os; ..\..\..\common_cortex\inc; ..\..\..\common; ..\..\..\tests\test_common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: test_CortexM0.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\..\common_cortex\src\stm32f070xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../common/: shell.c shell.h test_shell_func.c tn_sprintf.c utils.c
  group common_cortex
    ../../../common_cortex/src/: startup_stm32f070xb_iar.s stm32f0_uart.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c system_stm32f0xx.c
  group Include
    ../: prj_conf.h project_main.h stm32f0xx_conf.h tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M3
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
  group test_common
    ../../test_common/: test.h test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
