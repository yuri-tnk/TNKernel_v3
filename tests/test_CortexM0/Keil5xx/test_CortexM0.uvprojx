# Keil uVision project test_CortexM0.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Example_STM32F070R +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\;..\..\..\os;..\..\CortexM0_M7;..\..\..\common_cortex\inc;..\..\..\common;..\..\..\tests\test_common
  asm misc: --cpreproc
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group os
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
    ../../../os/: tn_utils.c tn_timer.c tn_task.c tn_sys.c tn_sem.c tn_mutex.c tn_mem.c tn_mailbox.c tn_event.c tn_dqueue.c tn.c tn_alloc.c
  group common_cortex
    ../../../common_cortex/src/: stm32f0_uart.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_rcc.c system_stm32f0xx.c stm32f0xx_usart.c
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
  group prg_base
    ../: project_main.c tn_user.c utils_arch.c
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
    ./: startup_stm32f0xx_keil.s
