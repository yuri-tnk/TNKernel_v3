# IAR project test_CortexM3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1776 NXP LPC1776
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\os; ..\..\..\common_cortex\inc; ..\..\..\common; ..\..\test_common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: test_CortexM3.hex
  ILINK.IlinkOutputFile: test_CortexM3.out
  ILINK.IlinkIcfFile: ..\..\..\common_cortex\src\LPC1766_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group common
    ../../../common/: shell.c shell.h test_shell_func.c tn_sprintf.c utils.c
  group common_cortex
    ../../../common_cortex/src/: lpc17xx_core.c lpc17xx_startup_hardware_init.S lpc17xx_uart.c system_lpc176x.c tn_LPC17XX_Startup_iar.s
  group Include
    ../: project_main.h tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M7
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
  group test_common
    ../../test_common/: test.h test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
