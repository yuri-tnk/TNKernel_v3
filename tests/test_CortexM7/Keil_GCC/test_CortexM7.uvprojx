# Keil uVision project test_CortexM7.uvprojx, settings and files
target Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZEYx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: test_CortexM7 +hex
  AfterMake: "C:\Program Files (x86)\GNU Tools ARM Embedded\5.3 2016q1\bin\arm-none-eabi-size.exe" -A ./objects/test_CortexM7.elf
  group common_cortex
    ../../../common_cortex/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f7_uart.c system_stm32f746.c tn_stm32f746_Startup_gcc.s
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
  group prj
    ../: project_main.c tn_user.c utils_arch.c
    ../../../common/: shell.c test_shell_func.c tn_sprintf.c utils.c
  group os
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7_asm.S tn_port_CortexM0_M7.c
    ../../../os/: tn.c tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c
  group include
    ../: prj_conf.h project_main.h stm32f7xx_conf.h tn_config.h
  group common
    ../../../common/: shell.c
