# IAR project test_CortexM7.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZE ST STM32F746ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_CORTEX_M7
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\os; ..\..\..\common_cortex\inc; ..\..\..\common; ..\..\..\tests\test_common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..\.
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common_cortex\src\stm32f746xE.icf
  ILINK.IlinkExtraOptions: --no_remove --no_fragments
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../common/: shell.c shell.h test_shell_func.c tn_sprintf.c utils.c
  group common_cortex
    ../../../common_cortex/src/: startup_stm32f746xx_iar.s stm32f4xx_dma.c stm32f4xx_gpio.c stm32f7_uart.c system_stm32f746.c
  group Include
    ../: prj_conf.h project_main.h stm32f7xx_conf.h tn_config.h
  group os
    ../../../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M7
    ../../../os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group Prj
    ../: project_main.c tn_user.c utils_arch.c
  group test_common
    ../../test_common/: test_common.c test_dqueue.c test_event.c test_mailbox.c test_mem.c test_mutex.c test_sem.c test_task.c test_timer.c test_utils.c
